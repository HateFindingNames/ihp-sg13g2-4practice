v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sg13g2_pr/npn13G2.sym} 160 -160 0 0 {name=Q1
model=npn13G2
spiceprefix=X
Nx=1
}
C {sg13g2_pr/npn13G2.sym} 320 -160 0 0 {name=Q2
model=npn13G2
spiceprefix=X
Nx=1
}
C {sg13g2_pr/rsil.sym} 180 -390 0 0 {name=R1
w=0.5e-6
l=0.5e-6
model=rsil
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rsil.sym} 340 -390 0 0 {name=R2
w=0.5e-6
l=0.5e-6
model=rsil
spiceprefix=X
b=0
m=1
}
